# Keil uVision project x500_motor_test.uvproj, settings and files
target TP_X500_001_MARK1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: X500_TEST_MARK1 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\MOTOR_SIDE;..\HARDWARE\FAN;..\HARDWARE\MOTOR_MOVE;..\HARDWARE\REMOTE;..\HARDWARE\VOICE;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\SENSOR;..\HARDWARE\USART;..\HARDWARE\CHARGER;..\HARDWARE\RTC;..\HARDWARE\POWER5V;..\HARDWARE\MOTOR_FAN
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/SENSOR/: sensor.c
    ../HARDWARE/MOTOR_MOVE/: motor_move.c
    ../HARDWARE/MOTOR_SIDE/: motor_side.c
    ../HARDWARE/MOTOR_FAN/: motor_fan.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/VOICE/: voice.c
    ../HARDWARE/POWER5V/: power5v.c
    ../HARDWARE/CHARGER/: charger.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
